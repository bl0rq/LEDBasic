#include "Palettes.h"

#include <string.h>

struct PaletteDef {
    const char* name;
    bool wrap;
    PaletteRgb colors[16];
};

// Colors copied from FastLED's predefined palettes (MIT).
static const PaletteDef kPalettes[] = {
    {"Rainbow", true, {
        {0xFF, 0x00, 0x00}, {0xD5, 0x2A, 0x00}, {0xAB, 0x55, 0x00}, {0xAB, 0x7F, 0x00},
        {0xAB, 0xAB, 0x00}, {0x56, 0xD5, 0x00}, {0x00, 0xFF, 0x00}, {0x00, 0xD5, 0x2A},
        {0x00, 0xAB, 0x55}, {0x00, 0x56, 0xAA}, {0x00, 0x00, 0xFF}, {0x2A, 0x00, 0xD5},
        {0x55, 0x00, 0xAB}, {0x7F, 0x00, 0x81}, {0xAB, 0x00, 0x55}, {0xD5, 0x00, 0x2B},
    }},
    {"Party", true, {
        {0x55, 0x00, 0xAB}, {0x84, 0x00, 0x7C}, {0xB5, 0x00, 0x4B}, {0xE5, 0x00, 0x1B},
        {0xE8, 0x17, 0x00}, {0xB8, 0x47, 0x00}, {0xAB, 0x77, 0x00}, {0xAB, 0xAB, 0x00},
        {0xAB, 0x55, 0x00}, {0xDD, 0x22, 0x00}, {0xF2, 0x00, 0x0E}, {0xC2, 0x00, 0x3E},
        {0x8F, 0x00, 0x71}, {0x5F, 0x00, 0xA1}, {0x2F, 0x00, 0xD0}, {0x00, 0x07, 0xF9},
    }},
    {"Cloud", true, {
        {0x00, 0x00, 0xFF}, {0x00, 0x00, 0x8B}, {0x00, 0x00, 0x8B}, {0x00, 0x00, 0x8B},
        {0x00, 0x00, 0x8B}, {0x00, 0x00, 0x8B}, {0x00, 0x00, 0x8B}, {0x00, 0x00, 0x8B},
        {0x00, 0x00, 0xFF}, {0x00, 0x00, 0x8B}, {0x87, 0xCE, 0xEB}, {0x87, 0xCE, 0xEB},
        {0xAD, 0xD8, 0xE6}, {0xFF, 0xFF, 0xFF}, {0xAD, 0xD8, 0xE6}, {0x87, 0xCE, 0xEB},
    }},
    {"Lava", false, {
        {0x00, 0x00, 0x00}, {0x80, 0x00, 0x00}, {0x00, 0x00, 0x00}, {0x80, 0x00, 0x00},
        {0x8B, 0x00, 0x00}, {0x8B, 0x00, 0x00}, {0x80, 0x00, 0x00}, {0x8B, 0x00, 0x00},
        {0x8B, 0x00, 0x00}, {0x8B, 0x00, 0x00}, {0xFF, 0x00, 0x00}, {0xFF, 0xA5, 0x00},
        {0xFF, 0xFF, 0xFF}, {0xFF, 0xA5, 0x00}, {0xFF, 0x00, 0x00}, {0x8B, 0x00, 0x00},
    }},
    {"Ocean", true, {
        {0x19, 0x19, 0x70}, {0x00, 0x00, 0x8B}, {0x19, 0x19, 0x70}, {0x00, 0x00, 0x80},
        {0x00, 0x00, 0x8B}, {0x00, 0x00, 0xCD}, {0x2E, 0x8B, 0x57}, {0x00, 0x80, 0x80},
        {0x5F, 0x9E, 0xA0}, {0x00, 0x00, 0xFF}, {0x00, 0x8B, 0x8B}, {0x64, 0x95, 0xED},
        {0x7F, 0xFF, 0xD4}, {0x2E, 0x8B, 0x57}, {0x00, 0xFF, 0xFF}, {0x87, 0xCE, 0xFA},
    }},
    {"Forest", false, {
        {0x00, 0x64, 0x00}, {0x00, 0x64, 0x00}, {0x55, 0x6B, 0x2F}, {0x00, 0x64, 0x00},
        {0x00, 0x80, 0x00}, {0x22, 0x8B, 0x22}, {0x6B, 0x8E, 0x23}, {0x00, 0x80, 0x00},
        {0x2E, 0x8B, 0x57}, {0x66, 0xCD, 0xAA}, {0x32, 0xCD, 0x32}, {0x9A, 0xCD, 0x32},
        {0x90, 0xEE, 0x90}, {0x7C, 0xFC, 0x00}, {0x66, 0xCD, 0xAA}, {0x22, 0x8B, 0x22},
    }},
    {"RainbowBands", true, {
        {0xFF, 0x00, 0x00}, {0x00, 0x00, 0x00}, {0xAB, 0x55, 0x00}, {0x00, 0x00, 0x00},
        {0xAB, 0xAB, 0x00}, {0x00, 0x00, 0x00}, {0x00, 0xFF, 0x00}, {0x00, 0x00, 0x00},
        {0x00, 0xAB, 0x55}, {0x00, 0x00, 0x00}, {0x00, 0x00, 0xFF}, {0x00, 0x00, 0x00},
        {0x55, 0x00, 0xAB}, {0x00, 0x00, 0x00}, {0xAB, 0x00, 0x55}, {0x00, 0x00, 0x00},
    }},
    {"Heat", false, {
        {0x00, 0x00, 0x00}, {0x33, 0x00, 0x00}, {0x66, 0x00, 0x00}, {0x99, 0x00, 0x00},
        {0xCC, 0x00, 0x00}, {0xFF, 0x00, 0x00}, {0xFF, 0x33, 0x00}, {0xFF, 0x66, 0x00},
        {0xFF, 0x99, 0x00}, {0xFF, 0xCC, 0x00}, {0xFF, 0xFF, 0x00}, {0xFF, 0xFF, 0x33},
        {0xFF, 0xFF, 0x66}, {0xFF, 0xFF, 0x99}, {0xFF, 0xFF, 0xCC}, {0xFF, 0xFF, 0xFF},
    }},
};

static const int kPaletteCount = (int)(sizeof(kPalettes) / sizeof(kPalettes[0]));

static uint8_t scale8(uint8_t value, uint8_t scale) {
    return (uint8_t)(((uint16_t)value * scale) >> 8);
}

static PaletteRgb blend(PaletteRgb a, PaletteRgb b, uint8_t towardB) {
    uint8_t keep = (uint8_t)(255 - towardB);
    PaletteRgb out;
    out.r = (uint8_t)(scale8(a.r, keep) + scale8(b.r, towardB));
    out.g = (uint8_t)(scale8(a.g, keep) + scale8(b.g, towardB));
    out.b = (uint8_t)(scale8(a.b, keep) + scale8(b.b, towardB));
    return out;
}

int paletteCount() { return kPaletteCount; }

const char* paletteName(int index) {
    if (index < 0 || index >= kPaletteCount) return kPalettes[0].name;
    return kPalettes[index].name;
}

int findPalette(const char* name) {
    if (!name) return -1;
    for (int i = 0; i < kPaletteCount; i++) {
        if (strcmp(kPalettes[i].name, name) == 0) return i;
    }
    return -1;
}

bool paletteWraps(int index) {
    if (index < 0 || index >= kPaletteCount) return true;
    return kPalettes[index].wrap;
}

PaletteRgb paletteColor(int index, int position, int brightness) {
    if (index < 0 || index >= kPaletteCount) index = 0;
    if (position < 0) position = 0;
    if (position > 255) position = 255;
    if (brightness < 0) brightness = 0;
    if (brightness > 255) brightness = 255;

    const PaletteDef& pal = kPalettes[index];
    int slot = position >> 4;
    int frac = position & 0x0F;
    PaletteRgb color = pal.colors[slot];
    if (frac != 0) {
        int next = slot + 1;
        if (next > 15) next = pal.wrap ? 0 : 15;
        if (!(slot == 15 && !pal.wrap)) {
            color = blend(color, pal.colors[next], (uint8_t)(frac << 4));
        }
    }
    if (brightness != 255) {
        uint8_t scale = brightness == 0 ? 0 : (uint8_t)(brightness + 1);
        color.r = scale8(color.r, scale);
        color.g = scale8(color.g, scale);
        color.b = scale8(color.b, scale);
    }
    return color;
}
